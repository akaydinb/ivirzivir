
#include "LedControl.h"
#define dataPin 12
#define clkPin  11
#define chipSel 10

// Four 8x8 LED Matrix displays are initialized
LedControl lc = LedControl(dataPin, clkPin, chipSel, 4);

unsigned long delaytime=1000;

void setup() {
  for(int i = 0; i < 4; i++)  {
    lc.shutdown(i,false);
    lc.setIntensity(i,0);
    lc.clearDisplay(i);
  }
}

byte dizi[20] = { 0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 0, 1, 2 };
byte pointer = 0;

unsigned char table[][8] = {
 { 0x7c, 0xc6, 0xce, 0xde, 0xf6, 0xe6, 0x7c, 0x00 },    // 0
 { 0x30, 0x70, 0x30, 0x30, 0x30, 0x30, 0xfc, 0x00 },    // 1
 { 0x78, 0xcc, 0x0c, 0x38, 0x60, 0xcc, 0xfc, 0x00 },    // 2
 { 0x78, 0xcc, 0x0c, 0x38, 0x0c, 0xcc, 0x78, 0x00 },    // 3
 { 0x1c, 0x3c, 0x6c, 0xcc, 0xfe, 0x0c, 0x1e, 0x00 },    // 4
 { 0xfc, 0xc0, 0xf8, 0x0c, 0x0c, 0xcc, 0x78, 0x00 },    // 5
 { 0x38, 0x60, 0xc0, 0xf8, 0xcc, 0xcc, 0x78, 0x00 },    // 6
 { 0xfc, 0xcc, 0x0c, 0x18, 0x30, 0x30, 0x30, 0x00 },    // 7
 { 0x78, 0xcc, 0xcc, 0x78, 0xcc, 0xcc, 0x78, 0x00 },    // 8
 { 0x78, 0xcc, 0xcc, 0x7c, 0x0c, 0x18, 0x70, 0x00 },    // 9
 { 0x30, 0x78, 0xcc, 0xcc, 0xfc, 0xcc, 0xcc, 0x00 },    // A
 { 0xfc, 0x66, 0x66, 0x7c, 0x66, 0x66, 0xfc, 0x00 },    // B
 { 0x3c, 0x66, 0xc0, 0xc0, 0xc0, 0x66, 0x3c, 0x00 },    // C
 { 0xf8, 0x6c, 0x66, 0x66, 0x66, 0x6c, 0xf8, 0x00 },    // D
 { 0xfe, 0x62, 0x68, 0x78, 0x68, 0x62, 0xfe, 0x00 },    // E
 { 0xfe, 0x62, 0x68, 0x78, 0x68, 0x60, 0xf0, 0x00 },    // F
 { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 }     // Space
};

void loop() { 
  for(int j = 0; j < 8; j++)  {
      lc.setRow(3, j, table[dizi[pointer    ]][j]);
      lc.setRow(2, j, table[dizi[pointer + 1]][j]);
      lc.setRow(1, j, table[dizi[pointer + 2]][j]);
      lc.setRow(0, j, table[dizi[pointer + 3]][j]);
  }

  delay(1000);
  pointer++;
  if (pointer > 16)   pointer = 0;
}
